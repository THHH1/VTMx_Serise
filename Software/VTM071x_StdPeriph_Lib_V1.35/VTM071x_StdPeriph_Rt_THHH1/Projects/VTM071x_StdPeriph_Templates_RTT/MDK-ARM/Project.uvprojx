# Keil uVision project Project.uvprojx, settings and files
target VTM32F071x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Project +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, DAPLINK_VERSION=250, DAPLINK_BUILD_KEY=0x9B939E8F, DAPLINK_HIC_ID=0x97969908
  c include: ..\..\VTM071x_StdPeriph_Templates_RTT;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\CMSIS\Device\MIC\VTM071x\Include;..\..\..\Libraries\VTM071x_StdPeriph_Driver\inc;..\..\..\Utilities;..\..\..\Utilities\VTM071x_EVAL;..\..\..\Utilities\VTM071x_EVAL\Common;..\..\..\3.1.5\components\device;..\..\..\3.1.5\components\finsh;..\..\..\3.1.5\components\include\drivers;..\..\..\3.1.5\include;..\..\..\3.1.5\libcpu;.\RTE\RTOS;.\RTE\Dev;.\RTE\VTM32F071x;.\RTE\OLED;.\RTE\Packages\CJSON;.\RTE\App
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1e000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../: system_VTM071x.c
    ../../../Libraries/CMSIS/Device/MIC/VTM071x/Source/Templates/ARM/: startup_VTM071x.s
  group User
    ../: main.c VTM071x_it.c
    ./RTE/RTOS/: config.h rtconfig.h system.c Task.c
  group DeviceDrivers
    ./RTE/Dev/: SysTick.c Exti.c USart.c Button.c BspTimer.c Adc.c Led.c Beep.c mailbox_test.c mempool_test.c BspEsp8266.c BMI160.c LM75BD.c
  group App
    ./RTE/App/: WifiCmdTest.c TemperatureUploadLocalSer.c NtpExample.c WeatherInfo.c
  group Packages
    ./RTE/Packages/CJSON/: cJSON.c cJSON_port.c cJSON_util.c
  group 096_OLED
    ./RTE/OLED/: oled.c
  group Utilities
    ../../../Utilities/VTM071x_EVAL/: VTM071x_eval.c
    ../../../Utilities/VTM071x_EVAL/Common/: VTM071x_eval_i2c_ee.c VTM071x_eval_spi.c
  group fish_mesh
    ./RTE/RTOS/: board.c finsh_port.c
    ../../../3.1.5/components/finsh/: cmd.c msh.c shell.c
  group RT_libcpu
    ../../../3.1.5/libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group RT_src
    ../../../3.1.5/components/device/: device.c
    ../../../3.1.5/src/: clock.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c components.c
  group StdPeriph_Driver
    ../../../Libraries/VTM071x_StdPeriph_Driver/src/: misc.c VTM071x_acmp.c VTM071x_adc.c VTM071x_dac.c VTM071x_dma.c VTM071x_flash.c VTM071x_gpio.c VTM071x_i2c.c VTM071x_iwdg.c VTM071x_maths.c VTM071x_mcpwm.c VTM071x_rcc.c VTM071x_rtc.c VTM071x_spi.c VTM071x_timer.c VTM071x_tsc.c VTM071x_usart.c VTM071x_wwdg.c
  group README
    ./RTE/Dev/: README.txt
