# Keil uVision project usbd_msc.uvprojx, settings and files
target USBD_MSC_VTM071x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: usbd_hid
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\CMSIS\Device\MIC\VTM071x\Include;..\..\..\Libraries\VTM071x_StdPeriph_Driver\inc;..\..\..\Libraries\VTM071x_USB_Device_Driver\inc;..\..\..\Libraries\VTM071x_USB_Device_Library\Core\inc;..\..\..\Libraries\VTM071x_USB_Device_Library\Class\msc\inc;..\..\..\Utilities\VTM071x_EVAL;..\..\..\Utilities\VTM071x_EVAL\Common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group App
    ../src/: app.c usb_bsp.c usbd_desc.c usbd_pwr.c usbd_usr.c usbd_storage_msd.c VTM071x_it.c
  group USB_Class
    ../../../Libraries/VTM071x_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_Drivers
    ../../../Libraries/VTM071x_USB_Device_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_Library
    ../../../Libraries/VTM071x_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group CMSIS
    ../../../Libraries/CMSIS/Device/MIC/VTM071x/Source/Templates/ARM/: startup_VTM071x.s
    ../../../Libraries/CMSIS/Device/MIC/VTM071x/Source/Templates/: system_VTM071x.c
  group StdPeriph_Driver
    ../../../Libraries/VTM071x_StdPeriph_Driver/src/: misc.c VTM071x_acmp.c VTM071x_adc.c VTM071x_dac.c VTM071x_dma.c VTM071x_flash.c VTM071x_gpio.c VTM071x_i2c.c VTM071x_iwdg.c VTM071x_maths.c VTM071x_mcpwm.c VTM071x_rcc.c VTM071x_rtc.c VTM071x_spi.c VTM071x_timer.c VTM071x_tsc.c VTM071x_usart.c VTM071x_wwdg.c
  group Utilities
    ../../../Utilities/VTM071x_EVAL/: VTM071x_eval.c
    ../../../Utilities/VTM071x_EVAL/Common/: VTM071x_eval_spi.c
