# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..; ..\..\..\Libraries\MT071x_StdPeriph_Driver\inc; ..\..\..\Libraries\CMSIS\Include; ..\..\..\Libraries\CMSIS\Device\MIC\MT071x\Include; ..\..\..\Utilities; ..\..\..\Utilities\MT071x_EVAL; ..\..\..\Utilities\MT071x_EVAL\Common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: MT071_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group User
    ../: main.c mt071x_it.c
  group StdPeriph_Driver
    ../../../Libraries/MT071x_StdPeriph_Driver/src/: misc.c mt071x_acmp.c mt071x_adc.c mt071x_dac.c mt071x_dma.c mt071x_flash.c mt071x_gpio.c mt071x_i2c.c mt071x_iwdg.c mt071x_maths.c mt071x_mcpwm.c mt071x_rcc.c mt071x_rtc.c mt071x_spi.c mt071x_timer.c mt071x_tsc.c mt071x_usart.c mt071x_wwdg.c
  group CMSIS
    ../../../Libraries/CMSIS/Device/MIC/MT071x/Source/Templates/IAR/: startup_mt071x.s
    ../: system_mt071x.c
  group Utilities
    ../../../Utilities/MT071x_EVAL/: mt071x_eval.c
    ../../../Utilities/MT071x_EVAL/Common/: mt071x_eval_i2c_ee.c mt071x_eval_spi.c
